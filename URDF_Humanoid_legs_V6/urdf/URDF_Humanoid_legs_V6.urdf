Commit message: 双足配置sim2sim

File: URDF_Humanoid_legs_V6/urdf/URDF_Humanoid_legs_V6.urdf (robot description, URDF)
Before this commit: robot URDF_Humanoid_legs_V6, 14 links, 13 joints
Links:
- link base_link: mass 6.0 -> 2.0
